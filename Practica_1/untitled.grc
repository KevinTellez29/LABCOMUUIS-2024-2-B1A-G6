options:
  parameters:
    generate_options: qt_gui
    id: Lab_comu_1
    output_language: python
    title: Practica_1A
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    label: Amplitud
    start: '0'
    step: '100e-3'
    stop: '5'
    value: '1'
  states: {state: disabled}
- name: frecuencia
  id: variable_qtgui_range
  parameters:
    label: Frecuencia en Hz
    start: '-16e3'
    step: '100'
    stop: 16e3
    value: '0'
  states: {}
- name: frecuencia
  id: variable
  parameters:
    value: '100'
  states: {state: disabled}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: Offset
    start: '-5'
    step: '100e-3'
    stop: '5'
    value: '0'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    label: Waveform
    labels: '["Constant", "Sine" , "Cosine", "Square", "Triangle", "Saw Tooth"]'
    num_opts: '0'
    options: '[100, 101, 102, 103, 104, 105]'
    type: raw
    value: '102'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '3'
    freq: frecuencia
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: '1024'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
